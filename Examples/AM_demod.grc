options:
  parameters:
    generate_options: qt_gui
    id: AM_demod
    output_language: python
    title: AM Demod
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Center_Frequency
    start: '9000'
    step: '100'
    stop: '6300000000'
    value: '1000000000'
  states: {}
- name: decimate_factor
  id: variable
  parameters:
    value: '256'
  states: {}
- name: reference_level
  id: variable_qtgui_range
  parameters:
    label: Reference_Level
    start: '-50'
    step: '1'
    stop: '23'
    value: '0'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Samp_rate
    start: '110000000'
    step: '1'
    stop: '130000000'
    value: '125000000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '6.25e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '6000'
    audio_stop: '8000'
    chan_rate: '48000'
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: '0.0654'
    min_freq: '-0.0654'
    w: '0.05'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.3'
    type: float
  states: {}
- name: htra_source_0
  id: htra_source
  parameters:
    center_freq: center_freq
    data_format: Complex16bit
    decim_factor: DECIM_256
    device_ip: 192.168.1.100
    device_num: '0'
    device_type: USB
    ref_level: reference_level
    sample_rate: samp_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '6000'
    decim: '4'
    gain: '1'
    samp_rate: '192000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimate_factor
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '1024'
    gui_hint: 1,0,1,2
    label: Power
    legend: 'False'
    name: Spectrum
    norm_window: 'True'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    units: dBm
    wintype: window.WIN_BLACKMAN
    ymin: '-160'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,1,1,1
    legend: 'False'
    name: PvT
    size: '4096'
    srate: '48000'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 0,0,1,1
    label1: Ch-I
    label2: Ch-Q
    name: IQvT
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Amplitude(V)
  states: {}

connections:
- [analog_agc_xx_0, '0', analog_pll_carriertracking_cc_0, '0']
- [analog_am_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_am_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [analog_pll_carriertracking_cc_0, '0', analog_am_demod_cf_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_0_0, '1']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [htra_source_0, '0', blocks_complex_to_float_0, '0']
- [htra_source_0, '0', low_pass_filter_0, '0']
- [htra_source_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_agc_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
