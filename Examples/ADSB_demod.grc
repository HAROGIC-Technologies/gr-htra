options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: adsb_rx
    output_language: python
    title: ADSB Demod
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Center_Frequency
    start: '9000'
    step: '100'
    stop: '6300000000'
    value: '1090000000'
  states: {}
- name: fs
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: reference_level
  id: variable_qtgui_range
  parameters:
    label: Reference_Level
    start: '-100'
    step: '1'
    stop: '23'
    value: '-80'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sample_rate
    start: '110000000'
    step: '1'
    stop: '130000000'
    value: '125000000'
  states: {}
- name: threshold
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,1,1,1
    label: Detection Threshold
    type: real
    value: '1e-9'
  states: {}
- name: adsb_decoder_0_0
  id: adsb_decoder
  parameters:
    error_corr: '"None"'
    msg_filter: '"Extended Squitter Only"'
    print_level: '"Verbose"'
  states: {}
- name: adsb_demod_0_0
  id: adsb_demod
  parameters:
    fs: fs
  states: {}
- name: adsb_framer_1_0
  id: adsb_framer
  parameters:
    fs: fs
    threshold: threshold
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: threshold
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: htra_source_0
  id: htra_source
  parameters:
    center_freq: center_freq
    data_format: Complex16bit
    decim_factor: DECIM_32
    device_ip: 192.168.1.100
    device_num: '0'
    device_type: USB
    ref_level: reference_level
    sample_rate: samp_rate
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 1,0,1,2
    label1: ''
    label2: ''
    legend: 'False'
    marker1: '0'
    nconnections: '2'
    size: int(fs*150e-6)
    srate: int(fs)
    tr_delay: '1.25e-6'
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"burst"'
    type: float
    update_time: 1.0/100.0
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    legend: 'False'
    marker1: '0'
    size: int(fs*150e-6)
    srate: int(fs)
    tr_delay: '1.25e-6'
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"burst"'
    type: float
    update_time: 1.0/100.0
    ymin: '0'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    fbw: '0.4'
    interp: '64'
    type: ccc
  states: {}
- name: zeromq_pub_msg_sink_0_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5001
    timeout: '10'
  states: {}

connections:
- [adsb_decoder_0_0, decoded, zeromq_pub_msg_sink_0_0, in]
- [adsb_demod_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [adsb_demod_0_0, demodulated, adsb_decoder_0_0, demodulated]
- [adsb_framer_1_0, '0', adsb_demod_0_0, '0']
- [analog_const_source_x_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_complex_to_mag_squared_0_0, '0', adsb_framer_1_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [htra_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_mag_squared_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
