options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Center_Frequency
    start: '9000'
    step: '100'
    stop: '6300000000'
    value: 202.928e6
  states: {}
- name: decimate_factor
  id: variable
  parameters:
    value: '32'
  states: {}
- name: reference_level
  id: variable_qtgui_range
  parameters:
    label: Reference_Level
    start: '-50'
    step: '1'
    stop: '23'
    value: '-30'
  states: {}
- name: sample_rate
  id: variable_qtgui_range
  parameters:
    label: Sample_rate
    start: '110000000'
    step: '1'
    stop: '130000000'
    value: 122.88e6
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '24000'
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1536'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '32'
    type: byte
  states: {}
- name: dab_dabplus_audio_decoder_ff_0
  id: dab_dabplus_audio_decoder_ff
  parameters:
    address: '462'
    bit_rate: '88'
    dab_mode: '1'
    output_float: 'True'
    protection: '2'
    samp_rate: '2048000'
    subch_size: '66'
  states: {}
- name: dab_fic_decode_0
  id: dab_fic_decode
  parameters:
    dab_mode: '1'
    print_channel_info: 'False'
    samp_rate: '2048000'
  states: {}
- name: dab_ofdm_demod_0
  id: dab_ofdm_demod
  parameters:
    autocorr_sr: 'True'
    correct_ffe: 'True'
    dab_mode: '1'
    eq_mag: 'True'
    input_fft: 'True'
    ppm_error: '0'
    samp_rate: '2048000'
    soft_bits: soft
  states: {}
- name: digital_mpsk_snr_est_cc_0
  id: digital_mpsk_snr_est_cc
  parameters:
    alpha: '0.001'
    tag_nsamples: '10000'
    type: '2'
  states: {}
- name: htra_source_0
  id: htra_source
  parameters:
    center_freq: center_freq
    decim_factor: DECIM_32
    ref_level: reference_level
    sample_rate: sample_rate
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '4096'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '2048000'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '15'
    interp: '8'
    type: ccc
  states: {}

connections:
- [blocks_vector_to_stream_0, '0', digital_mpsk_snr_est_cc_0, '0']
- [blocks_vector_to_stream_0_1, '0', blocks_null_sink_0_1, '0']
- [dab_dabplus_audio_decoder_ff_0, '0', audio_sink_0, '0']
- [dab_dabplus_audio_decoder_ff_0, '1', audio_sink_0, '1']
- [dab_fic_decode_0, '0', blocks_vector_to_stream_0_1, '0']
- [dab_ofdm_demod_0, '0', blocks_vector_to_stream_0, '0']
- [dab_ofdm_demod_0, '0', dab_dabplus_audio_decoder_ff_0, '0']
- [dab_ofdm_demod_0, '0', dab_fic_decode_0, '0']
- [digital_mpsk_snr_est_cc_0, '0', qtgui_const_sink_x_1, '0']
- [htra_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', dab_ofdm_demod_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
