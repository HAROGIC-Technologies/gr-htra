options:
  parameters:
    generate_options: qt_gui
    id: IQ_streaming
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Center_Frequency
    start: '9000'
    step: '100'
    stop: '6300000000'
    value: '1000000000'
  states: {}
- name: decimate_factor
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,0
    label: Decimate_Factor
    labels: '[]'
    num_opts: '0'
    options: '[1,2,4,8,16,32,64,128,256,512,1024,2048,4096]'
    type: int
    value: '16'
  states: {}
- name: reference_level
  id: variable_qtgui_range
  parameters:
    label: Reference_Level
    start: '-50'
    step: '1'
    stop: '23'
    value: '0'
  states: {}
- name: sample_rate
  id: variable_qtgui_range
  parameters:
    label: Sample_rate
    start: '110000000'
    step: '1'
    stop: '130000000'
    value: '122880000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '32768'
    type: complex
  states: {}
- name: htra_source_0
  id: htra_source
  parameters:
    center_freq: center_freq
    decim_factor: decimate_factor
    ref_level: reference_level
    sample_rate: sample_rate
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: sample_rate/decimate_factor
    fc: center_freq
    fftsize: '1024'
    rate: '1000'
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [htra_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
