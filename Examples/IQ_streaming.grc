options:
  parameters:
    generate_options: qt_gui
    id: IQ_streaming
    output_language: python
    title: IQ Streaming
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Center_Frequency
    start: '9000'
    step: '100'
    stop: '6300000000'
    value: '1000000000'
  states: {}
- name: center_freq_0
  id: variable_qtgui_range
  parameters:
    label: Center_Frequency
    start: '9000'
    step: '100'
    stop: '6300000000'
    value: '1000000000'
  states: {}
- name: decimate_factor
  id: variable
  parameters:
    value: '64'
  states: {}
- name: reference_level
  id: variable_qtgui_range
  parameters:
    label: Reference_Level
    start: '-50'
    step: '1'
    stop: '23'
    value: '-10'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sample_rate
    start: '110000000'
    step: '1'
    stop: '130000000'
    value: '125000000'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: htra_source_0
  id: htra_source
  parameters:
    center_freq: center_freq
    data_format: Complex16bit
    decim_factor: DECIM_64
    device_ip: 192.168.1.100
    device_num: '0'
    device_type: USB
    ref_level: reference_level
    sample_rate: samp_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimate_factor
    fc: center_freq
    fftsize: '1024'
    gui_hint: 2,0,1,2
    label: Power
    legend: 'False'
    name: Spectrum
    type: complex
    units: dBm
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 0,0,1,2
    label1: Ch-I
    label2: Ch-Q
    name: IQvT
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Amplitude(V)
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/decimate_factor
    fc: center_freq
    fftsize: '1024'
    gui_hint: 1,0,1,2
    name: Waterfull
    type: complex
  states: {}

connections:
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_0, '1']
- [htra_source_0, '0', blocks_complex_to_float_0, '0']
- [htra_source_0, '0', qtgui_freq_sink_x_0, '0']
- [htra_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
