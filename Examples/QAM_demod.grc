<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>QAM Demod</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>1000000000</value></param>
<param><key>label</key><value>Center_Frequency</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>9000</value></param>
<param><key>step</key><value>100</value></param>
<param><key>stop</key><value>40000000000</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>decimate_factor</value></param>
<param><key>value</key><value>128</value></param>
<param><key>label</key><value>Decimate_Factor</value></param>
<param><key>labels</key><value>["1", "2", "4", "8", "16", "32", "64", "128", "256", "512", "1024", "2048", "4096"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[1, 2, 4, 8, 16, 32, 64, 128, 256, 512, 1024, 2048, 4096]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>excess_bw</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>reference_level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Reference_Level</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-50</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>23</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>125000000</value></param>
<param><key>label</key><value>Sample_rate</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>110000000</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>130000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>variable_constellation_16qam</value></param>
<param><key>type</key><value>16qam</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>variable_constellation_64qam</value></param>
<param><key>const_points</key><value>[complex(i, q) for q in (-7,-5,-3,-1,1,3,5,7) for i in (-7,-5,-3,-1,1,3,5,7)]</value></param>
<param><key>type</key><value>calcdist</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>[(((s &amp; 7) ^ ((s &amp; 7)&gt;&gt;1) ^ ((s &amp; 7)&gt;&gt;2)) * 8) |(((s&gt;&gt;3) &amp; 7) ^ (((s&gt;&gt;3) &amp; 7)&gt;&gt;1) ^ (((s&gt;&gt;3) &amp; 7)&gt;&gt;2))for s in range(64)]</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>attack_rate</key><value>1e-2</value></param>
<param><key>decay_rate</key><value>1e-3</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>num_items</key><value>100000</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>32</value></param>
<param><key>init_phase</key><value>16</value></param>
<param><key>loop_bw</key><value>0.00628</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>taps</key><value>firdes.root_raised_cosine(32, 32, 1.0, 0.35, 11*32*4)</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>import numpy as np
from gnuradio import gr, digital

class OptimizedDDPLL(gr.sync_block):
    def __init__(self, Loop_BandWidth=0.01, Damping_Factor=1, Constellation_Object=digital.bpsk_constellation()):
        gr.sync_block.__init__(
            self,
            name='DDPLL',
            in_sig=[np.complex64],
            out_sig=[np.complex64]
        )
        
        self.Loop_BandWidth = Loop_BandWidth
        self.Damping_Factor = Damping_Factor
        self.Constellation_Object = Constellation_Object

 
        if hasattr(Constellation_Object, 'points'):
            points = Constellation_Object.points()
        else:
            points = Constellation_Object
            

        self.real_levels = np.unique(np.real(points))
        self.imag_levels = np.unique(np.imag(points))
        

        self.phase = 0.0
        self.freq = 0.0
        self.update_loop_coefficients()
        

        self.max_freq_step = 0.05

    def update_loop_coefficients(self):
        bw = self.Loop_BandWidth
        damp = self.Damping_Factor
        K = 2.0
        denom = 1.0 + 2.0 * damp * bw + bw * bw
        self.alpha = (4.0 * damp * bw * K) / denom
        self.beta = (4.0 * bw * bw * K) / denom

    def fast_decision(self, symbol):
        real_decision = self.real_levels[np.argmin(np.abs(self.real_levels - np.real(symbol)))]
        imag_decision = self.imag_levels[np.argmin(np.abs(self.imag_levels - np.imag(symbol)))]
        return real_decision + 1j * imag_decision

    def work(self, input_items, output_items):
        inputs = input_items[0]
        outputs = output_items[0]
        
        for i in range(len(inputs)):
      
            rotated = inputs[i] * np.exp(-1j * self.phase)

            decision = self.fast_decision(rotated)

            if abs(decision) &gt; 1e-10:
                error = np.angle(rotated * np.conj(decision))
                error = max(min(error, np.pi/4), -np.pi/4)
            else:
                error = 0.0
            

            freq_update = self.beta * error
            if abs(freq_update) &gt; self.max_freq_step:
                freq_update = np.sign(freq_update) * self.max_freq_step
            
            self.freq += freq_update
            self.phase += self.freq + self.alpha * error
            
            if self.phase &gt; np.pi:
                self.phase -= 2 * np.pi
            elif self.phase &lt; -np.pi:
                self.phase += 2 * np.pi
            
            outputs[i] = rotated
        
        return len(outputs)
</value></param>
<param><key>Constellation_Object</key><value>variable_constellation_16qam</value></param>
<param><key>Damping_Factor</key><value>1</value></param>
<param><key>Loop_BandWidth</key><value>0.01</value></param>
</block>
<block>
<key>htra_htra_source</key>
<param><key>id</key><value>htra_htra_source_0</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>data_format</key><value>Complex16bit</value></param>
<param><key>decim_factor</key><value>128</value></param>
<param><key>device_num</key><value>0</value></param>
<param><key>device_ip</key><value>192.168.1.100</value></param>
<param><key>device_type</key><value>USB</value></param>
<param><key>ref_level</key><value>reference_level</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0_0</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>Constellation</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>xmax</key><value>1.5</value></param>
<param><key>xmin</key><value>-1.5</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>-1.5</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate/decimate_factor</value></param>
<param><key>fc</key><value>center_freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>1,0,1,2</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>Spectrum</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>label</key><value>Power</value></param>
<param><key>units</key><value>dBm</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Ch_I</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Ch_Q</value></param>
<param><key>name</key><value>IQvT</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>yunit</key><value>V</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>samp_rate</value></param>
<param><key>fbw</key><value>0.4</value></param>
<param><key>interp</key><value>4*symbol_rate*decimate_factor</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>alpha</key><value>excess_bw</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>ntaps</key><value>11*sps*3</value></param>
<param><key>samp_rate</key><value>symbol_rate*4</value></param>
<param><key>sym_rate</key><value>symbol_rate</value></param>
</block>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>htra_htra_source_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>htra_htra_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>htra_htra_source_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
