options:
  parameters:
    generate_options: qt_gui
    id: QAM
    output_language: python
    title: QAM Demod
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Center_Frequency
    start: '9000'
    step: '100'
    stop: '6300000000'
    value: '1000000000'
  states: {}
- name: decimate_factor
  id: variable
  parameters:
    value: '64'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: reference_level
  id: variable_qtgui_range
  parameters:
    label: Reference_Level
    start: '-50'
    step: '1'
    stop: '23'
    value: '0'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Samp_rate
    start: '110000000'
    step: '1'
    stop: '130000000'
    value: '125000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: variable_constellation_16qam
  id: variable_constellation
  parameters:
    const_points: '[complex(i, q) for q in (-7,-5,-3,-1,1,3,5,7) for i in (-7,-5,-3,-1,1,3,5,7)]'
    normalization: digital.constellation.POWER_NORMALIZATION
    precision: '8'
    sym_map: '[(((s & 7) ^ ((s & 7)>>1) ^ ((s & 7)>>2)) * 8) |(((s>>3) & 7) ^ (((s>>3) & 7)>>1) ^ (((s>>3) & 7)>>2))for s in range(64)]'
    type: 16qam
  states: {}
- name: variable_constellation_64qam
  id: variable_constellation
  parameters:
    const_points: '[complex(i, q) for q in (-7,-5,-3,-1,1,3,5,7) for i in (-7,-5,-3,-1,1,3,5,7)]'
    dims: '1'
    normalization: digital.constellation.POWER_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[(((s & 7) ^ ((s & 7)>>1) ^ ((s & 7)>>2)) * 8) |(((s>>3) & 7) ^ (((s>>3) & 7)>>1) ^ (((s>>3) & 7)>>2))for s in range(64)]'
    type: calcdist
  states: {}
- name: analog_agc2_xx_0_0_1
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-2'
    decay_rate: '1e-3'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '100000'
    type: complex
  states: {}
- name: digital_symbol_sync_xx_0_1_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: variable_constellation_16qam
    damping: '1'
    loop_bw: 0.0628*0.1
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    Constellation_Object: variable_constellation_16qam
    Damping_Factor: '1'
    Loop_BandWidth: 0.0628*0.5
    _source_code: |
      import numpy as np
      from gnuradio import gr, digital

      class OptimizedDDPLL(gr.sync_block):
          def __init__(self, Loop_BandWidth=0.01, Damping_Factor=1, Constellation_Object=digital.bpsk_constellation()):
              gr.sync_block.__init__(
                  self,
                  name='DDPLL',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              
              self.Loop_BandWidth = Loop_BandWidth
              self.Damping_Factor = Damping_Factor
              self.Constellation_Object = Constellation_Object

       
              if hasattr(Constellation_Object, 'points'):
                  points = Constellation_Object.points()
              else:
                  points = Constellation_Object
                  

              self.real_levels = np.unique(np.real(points))
              self.imag_levels = np.unique(np.imag(points))
              

              self.phase = 0.0
              self.freq = 0.0
              self.update_loop_coefficients()
              

              self.max_freq_step = 0.05

          def update_loop_coefficients(self):
              bw = self.Loop_BandWidth
              damp = self.Damping_Factor
              K = 2.0
              denom = 1.0 + 2.0 * damp * bw + bw * bw
              self.alpha = (4.0 * damp * bw * K) / denom
              self.beta = (4.0 * bw * bw * K) / denom

          def fast_decision(self, symbol):
              real_decision = self.real_levels[np.argmin(np.abs(self.real_levels - np.real(symbol)))]
              imag_decision = self.imag_levels[np.argmin(np.abs(self.imag_levels - np.imag(symbol)))]
              return real_decision + 1j * imag_decision

          def work(self, input_items, output_items):
              inputs = input_items[0]
              outputs = output_items[0]
              
              for i in range(len(inputs)):
            
                  rotated = inputs[i] * np.exp(-1j * self.phase)

                  decision = self.fast_decision(rotated)

                  if abs(decision) > 1e-10:
                      error = np.angle(rotated * np.conj(decision))
                      error = max(min(error, np.pi/4), -np.pi/4)
                  else:
                      error = 0.0
                  

                  freq_update = self.beta * error
                  if abs(freq_update) > self.max_freq_step:
                      freq_update = np.sign(freq_update) * self.max_freq_step
                  
                  self.freq += freq_update
                  self.phase += self.freq + self.alpha * error
                  
                  if self.phase > np.pi:
                      self.phase -= 2 * np.pi
                  elif self.phase < -np.pi:
                      self.phase += 2 * np.pi
                  
                  outputs[i] = rotated
              
              return len(outputs)
  states: {}
- name: htra_source_0_0_1
  id: htra_source
  parameters:
    center_freq: center_freq
    data_format: Complex16bit
    decim_factor: DECIM_64
    device_ip: 192.168.1.100
    device_num: '0'
    device_type: USB
    ref_level: reference_level
    sample_rate: samp_rate
  states: {}
- name: qtgui_const_sink_x_0_1_0_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0,1,1,1
    legend: 'False'
    name: Constellation
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimate_factor
    fc: center_freq
    fftsize: '512'
    gui_hint: 1,0,1,2
    label: Power
    legend: 'False'
    name: Spectrum
    type: complex
    units: dBm
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 0,0,1,1
    label1: Ch-I
    label2: Ch-Q
    name: IQvT
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Amplitude(V)
  states: {}
- name: rational_resampler_xxx_0_0_1
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    fbw: '0.4'
    interp: 4*symbol_rate*decimate_factor
    type: ccc
  states: {}
- name: root_raised_cosine_filter_0_0_1
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    decim: '1'
    gain: '1'
    ntaps: 11*sps*3
    samp_rate: symbol_rate*4
    sym_rate: symbol_rate
    type: fir_filter_ccf
  states: {}

connections:
- [analog_agc2_xx_0_0_1, '0', digital_symbol_sync_xx_0_1_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_0, '1']
- [blocks_skiphead_0, '0', epy_block_0, '0']
- [digital_symbol_sync_xx_0_1_0, '0', blocks_skiphead_0, '0']
- [epy_block_0, '0', qtgui_const_sink_x_0_1_0_0_0, '0']
- [htra_source_0_0_1, '0', blocks_complex_to_float_0, '0']
- [htra_source_0_0_1, '0', qtgui_freq_sink_x_0, '0']
- [htra_source_0_0_1, '0', rational_resampler_xxx_0_0_1, '0']
- [rational_resampler_xxx_0_0_1, '0', root_raised_cosine_filter_0_0_1, '0']
- [root_raised_cosine_filter_0_0_1, '0', analog_agc2_xx_0_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
