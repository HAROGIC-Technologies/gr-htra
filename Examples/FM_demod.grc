options:
  parameters:
    generate_options: qt_gui
    id: FM_demod
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Center_Frequency
    start: '9000'
    step: '100'
    stop: '6300000000'
    value: '97500000'
  states: {}
- name: decimate_factor
  id: variable
  parameters:
    value: '64'
  states: {}
- name: reference_level
  id: variable_qtgui_range
  parameters:
    label: Reference_Level
    start: '-50'
    step: '1'
    stop: '23'
    value: '-30'
  states: {}
- name: sample_rate
  id: variable_qtgui_range
  parameters:
    label: Sample_rate
    start: '110000000'
    step: '1'
    stop: '130000000'
    value: '122880000'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '8'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: '384000'
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.3'
    type: float
  states: {}
- name: htra_source_0
  id: htra_source
  parameters:
    center_freq: center_freq
    decim_factor: DECIM_64
    ref_level: reference_level
    sample_rate: sample_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate/decimate_factor
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '1024'
    norm_window: 'True'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    wintype: window.WIN_BLACKMAN
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '4096'
    srate: 3.84e3/5
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate/decimate_factor
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    type: ccc
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_fm_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [htra_source_0, '0', qtgui_freq_sink_x_0, '0']
- [htra_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [htra_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_fm_demod_cf_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
